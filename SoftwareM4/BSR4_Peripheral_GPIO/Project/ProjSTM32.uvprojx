# Keil uVision project ProjSTM32.uvprojx, settings and files
target STM32F303C (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F303CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303C
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, ARM_MATH_CM4, STM32F303xC
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F3xx_HAL_Driver\Inc;..\Libraries\STM32F3xx_HAL_Driver\Inc\Legacy;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f303xc.s system_stm32f3xx.c
  group Library
    ../Libraries/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c
    ../Program/: stm32f3xx_hal_conf.h
  group Driver
    ../Program/drivers/: stm32f3_msp.c stm32f3_delay.c
  group Program
    ../Program/: main.c stm32f3xx_bsp.c stm32f3xx_it.c boardConfig.h
