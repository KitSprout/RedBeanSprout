# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F303C (ARM-ADS)
  device: STM32F303CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303C
  c flags: uC99=1 wLevel=2
  c define: STM32F303xC, USE_STDPERIPH_DRIVER, ARM_MATH_CM4
  c include: ..\;.\RTE;.\RTE\Device\STM32F303CB;.\RTE\STM32F30x_StdPeriph_Driver\src;.\RTE\STM32F30x_StdPeriph_Driver\inc;..\Program;..\Program\Algorithms;..\Program\Dirvers;..\Program\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Library
    ./RTE/STM32F30x_StdPeriph_Driver/src/: stm32f30x_rcc.c stm32f30x_tim.c stm32f30x_gpio.c stm32f30x_spi.c
    ./RTE/Device/STM32F303CB/: stm32f30x_conf.h
  group Driver
    ../Program/Dirvers/: stm32f3_delay.c stm32f3_spi.c
  group Program
    ../Program/: experiment_stm32f3.c experiment_stm32f3_it.c app_waveForm.c
  group Module
    ../Program/Modules/: module_ili9341.c
  group Algorithm
    ../Program/Algorithms/: algorithm_string.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.3.0
