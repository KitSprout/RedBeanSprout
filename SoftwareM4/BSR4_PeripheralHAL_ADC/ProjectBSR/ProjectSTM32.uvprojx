# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F303C (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00003000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303C
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F303x8, ARM_MATH_CM4, __FPU_PRESENT = 1,USE_FULL_ASSERT
  c include: ..\;..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F3xx_HAL_Driver\Inc;..\Libraries\STM32F3xx_HAL_Driver\Inc\Legacy;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f303x8.s system_stm32f3xx.c
  group Library
    ../Libraries/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
    ../Program/: stm32f3xx_hal_conf.h
  group Driver
    ../Program/drivers/: stm32f3_delay.c stm32f3_adc.c stm32f3_usart.c
  group Program
    ../Program/: experiment_stm32f3.c experiment_stm32f3_it.c experiment_stm32f3_msp.c
  group Module
    ../Program/modules/: module_serial.c
  group Algorithm
    ../Program/algorithms/: algorithm_string.c
