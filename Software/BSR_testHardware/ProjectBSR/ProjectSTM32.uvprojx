# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F103C (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32F103C
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB, ARM_MATH_CM3
  c include: ..\;..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\Libraries\STM32F1xx_HAL_Driver\Inc\Legacy;..\Libraries\STM32_USB_Device_Library\Core\Inc;..\Libraries\STM32_USB_Device_Library\Class\CDC\Inc;..\Libraries\STM32_USB_Device_Library;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f103xb.s system_stm32f1xx.c
  group Library
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
    ../Program/: stm32f1xx_hal_conf.h
  group Driver
    ../Program/drivers/: stm32f1_delay.c stm32f1_usb.c
  group Program
    ../Program/: experiment_stm32f1.c experiment_stm32f1_it.c experiment_stm32f1_msp.c
  group USB_Device
    ../Libraries/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Libraries/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Libraries/STM32_USB_Device_Library/: usbd_conf.c usbd_desc.c
