# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F103C (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32F103C
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Program;..\Program\Algorithms;..\Program\Dirvers;..\Program\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group Driver
    ../Program/Dirvers/: stm32f1_delay.c
  group Program
    ../Program/: experiment_stm32f1.c
  group ::Device
    RTE/Device/STM32F103CB/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
