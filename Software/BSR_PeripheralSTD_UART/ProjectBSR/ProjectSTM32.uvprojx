# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F103C (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c
  group Library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
    ../Program/: stm32f10x_conf.h
  group Driver
    ../Program/drivers/: stm32f1_delay.c stm32f1_usart.c
  group Program
    ../Program/: main.c beanSproutR.c beanSproutR_bsp.c beanSproutR_it.c
  group Module
    ../Program/modules/: module_serial.c
  group Algorithm
    ../Program/algorithms/: algorithm_string.c
